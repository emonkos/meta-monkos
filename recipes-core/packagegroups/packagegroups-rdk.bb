DESCRIPTION = "For RDK related components"

inherit packagegroup

PACKAGES = "\
    packagegroup-rdk \
    "

RDEPENDS_packagegroup-rdk = "\
    iarmbus \
    "
