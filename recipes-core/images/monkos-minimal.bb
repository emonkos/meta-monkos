SUMMARY = "Monk OS minimal device boot image"

LICENSE = "CLOSED"

include recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += " \
  "
